# Keil uVision project Vlaga.uvprojx, settings and files
target STM32 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Vlaga
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.cpp main.h
  group Peripherals
    ./: dma.cpp dma.h leds.cpp leds.h spi.cpp spi.h time.cpp time.h
  group VLG_InertialSensor
    ./: mpu9250_regs.h VLG_InertialSensor.cpp VLG_InertialSensor.h
  group VLG_Compass
    ./: ak8963_regs.h VLG_Compass.cpp VLG_Compass.h
software components: CMSIS:CORE 4.3.0, Device:Startup 2.4.0

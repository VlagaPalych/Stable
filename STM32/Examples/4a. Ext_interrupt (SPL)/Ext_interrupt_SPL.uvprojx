# Keil uVision project Ext_interrupt_SPL.uvprojx, settings and files
target STM32 (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) IRAM2(0x10000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Ext_interrupt_SPL
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\4a. Ext_interrupt (SPL)
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Source files
    ./: main.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.2.0
